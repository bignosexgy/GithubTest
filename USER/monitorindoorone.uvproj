# Keil uVision project monitorindoorone.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: monitorindoorone +hex
  c flags: Optim=1 oTime=1 OneElfS=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\MY-GPIO;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\STM32F10x_FWLib\src;..\HARDWARE\ADC;..\HARDWARE\BASIC;..\HARDWARE\Control;..\HARDWARE\EXTI;..\HARDWARE\flash;..\HARDWARE\key;..\HARDWARE\RTC;..\HARDWARE\TIMER;..\HARDWARE\vac;..\HARDWARE\SPI;..\HARDWARE\IIC;..\I2C;..\HARDWARE\CRC;..\HARDWARE\IIC;..\Mass_Storage\inc;..\HARDWARE\BASIC;..\HARDWARE\VCNL4000;..\HARDWARE\OLED;..\HARDWARE\HT1632
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ../CORE/: startup_stm32f10x_hd.s
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c main_v1.0.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/ff9/: diskio.c
  group HARDWARE
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/flash/: flash.c
    ../HARDWARE/MY-GPIO/: gpio.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/TIMER/: task.c timer.c
    ../HARDWARE/SPI/: spi.c spi_flash.c 6658spi.c
    ../HARDWARE/CRC/: crc.c
    ../HARDWARE/IIC/: EC808.c SHT21.c
    ../HARDWARE/key/: key.c
    ../HARDWARE/VCNL4000/: i2c.c vcnl4000.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/HT1632/: ht1632.c
  group CORE
    ../CORE/: core_cm3.c
  group FWlib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
