# Keil uVision project LED.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LED +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\MY-GPIO;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\EXTI;..\HARDWARE\BASIC;..\HARDWARE\RTC;..\HARDWARE\HT1622;..\HARDWARE\ADC;..\STM32F10x_FWLib\inc;..\HARDWARE\TIMER;..\HARDWARE\key;..\HARDWARE\vac;..\HARDWARE\runtime;..\HARDWARE\flash
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c main_v1.8.c
  group HARDWARE
    ../HARDWARE/MY-GPIO/: gpio.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/HT1622/: HT1622.C
    ../HARDWARE/TIMER/: timer.c task.c
    ../HARDWARE/key/: key.c
    ../HARDWARE/vac/: vac.c
    ../HARDWARE/runtime/: runtime.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/BASIC/: basic.c
    ../HARDWARE/flash/: flash.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_dma.c stm32f10x_adc.c stm32f10x_flash.c stm32f10x_iwdg.c
